# Keil uVision project Smpl_HID_IO.uvprojx, settings and files
target Smpl_HID_IO (ARM-ADS)
  device: NUC140VE3CN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.3
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Smpl_HID_IO +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  c include: .\;.\Include;.\Include\Driver;.\Include\NUC1xx-LB_002;.\Include\System;.\Include\USB;.\Include\CoreSupport;.\Src;.\Include\DeviceSupport\Nuvoton\NUC1xx
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ./Include/CoreSupport/: core_cm0.c
    ./Include/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    ./Include/DeviceSupport/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
  group Source files
    ./: Smpl_HID_IO.c HID_API.c HIDSysIO.c V6MDebug.c Motor_Ctrl.c
  group LCD files
    C:/Nuvoton/BSP_Library/NUC100SeriesBSP_CMSIS_v1.05.003/NuvotonPlatform_Keil/Src/NUC1xx-LB_002/: LCD_Driver.c Ascii_Table.C
  group Library files
    ./Src/Driver/: DrvGPIO.c DrvPWM.c DrvSYS.c DrvUART.c DrvUSB.c retarget.c
