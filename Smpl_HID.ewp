# IAR project Smpl_HID.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NUC100 series Nuvoton NUC100 series (NUC100,NUC101,NUC102,NUC120,NUC122,NUC130,NUC140)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; $PROJ_DIR$..\..\..\..\Include; $PROJ_DIR$..\..\..\..\Include\Driver; $PROJ_DIR$..\..\..\..\Include\System; $PROJ_DIR$..\..\..\..\Include\NUC1xx-LB_002; $PROJ_DIR$..\..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx; $PROJ_DIR$..\..\..\..\Include\USB
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Smpl_HID.bin
  ILINK.IlinkOutputFile: Smpl_HID.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS Files
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/startup/iar/: startup_NUC1xx.s
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
  group LCD Files
    ../../../Src/NUC1xx-LB_002/: Ascii_Table.C LCD_Driver.c
  group Library Files
    ../../../Src/Driver/: DrvGPIO.c DrvSYS.c DrvUART.c DrvUSB.c retarget.c
  group Source Files
    ./: HID_API.c HIDSysIO.c Smpl_HID_IO.c V6MDebug.c
